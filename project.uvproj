# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group intelligent car
    ./: main.c motor.c motor.h move.c timer_PWM.c timer_PWM.h UT.c UT.h bluetooth.c bluetooth.h Delay.c Delay.h move.h Tracking.c Servo.c Servo.h Tracking.h
